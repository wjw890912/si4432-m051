# Keil uVision project SI4432_86开关.uvproj, settings and files
target 86盒开关程序 (ARM-ADS)
  device: M058LBN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: SI4432_86开关 +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\CMSIS;..\CMSIS\CM0\CoreSupport;..\CMSIS\CM0\DeviceSupport;..\FMC;..\GPIO;..\Include;..\Lib;..\MAIN;..\SI4432Protocol;..\SI4432_Driver;..\USART
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group app
    ../MAIN/: main.c
  group wangjunwei
    ../GPIO/: GPIO.c
    ../FMC/: FMC.c
    ../SI4432_Driver/: SI4432.c
  group cmsis
    ../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: system_M051Series.c
    ../CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/startup/arm/: startup_M051Series.s
  group lib
    ../Lib/: DrvADC.c DrvEBI.c DrvFMC.c DrvGPIO.c DrvI2C.c DrvPWM.c DrvSPI.c DrvSYS.c DrvTIMER.c DrvUART.c retarget.c
  group si4432_protocol
    ../SI4432Protocol/: SI4432_proto.c
